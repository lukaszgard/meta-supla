SRC_URI = "git://github.com/SUPLA/supla-core.git;protocol=https"
SRCREV = "0bfe2a48775b1b524f15e9c41684db08b31c6c67"
