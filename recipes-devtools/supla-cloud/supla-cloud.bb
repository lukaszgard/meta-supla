# Copyright (C) 2017 Gardon Lukasz <garjack555@gmail.com>

DESCRIPTION = "Software for executive devices built based on Raspberry PI, Arduino or ESP8266 microcomputer."
HOMEPAGE = "https://www.supla.org/en/"
LICENSE = "CLOSED"

PR = "r1"

SRC_URI = "git://github.com/SUPLA/supla-cloud.git;protocol=https"
SRCREV = "e9757f0d9baceae963ff3a469df4e87e2fc37e0d"

S = "${WORKDIR}/git"
